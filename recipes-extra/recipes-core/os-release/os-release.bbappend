# Force os-release to always get the right version id info
do_compile[nostamp] = "1"
