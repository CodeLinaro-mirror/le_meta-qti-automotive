EXTRA_OECONF:append = " --with-selinux=no"
