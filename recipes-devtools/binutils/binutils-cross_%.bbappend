FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-AArch64-gas-Add-support-for-oryon-1.patch"
