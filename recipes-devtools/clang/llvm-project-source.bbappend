FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-AArch64-Add-support-for-Qualcomm-Oryon-processor.patch "
