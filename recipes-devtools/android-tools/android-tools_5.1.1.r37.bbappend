# Only install adb tools
TOOLS = "adb"

