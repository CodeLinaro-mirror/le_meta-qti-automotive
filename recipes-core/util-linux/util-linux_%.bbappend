RRECOMMENDS:${PN}:remove = "${PN}-su ${PN}-kill"
