
VOLATILE_BINDS = "\
/var/build.prop /etc/build.prop\n\
/var/data /etc/data/\n\
/var/usb /etc/usb/\n\
/var/misc/wifi /etc/misc/wifi/\n\
/var/bluetooth /etc/bluetooth/\n\
/var/allplay /etc/allplay/\n\
/var/gptp_cfg.ini /etc/gptp_cfg.ini\n\
/var/smack/accesses.d /etc/smack/accesses.d/\n\
"

