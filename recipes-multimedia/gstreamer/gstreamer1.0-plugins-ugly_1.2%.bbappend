# remove mpeg2dec, for license issue.
PACKAGECONFIG:remove = "mpeg2dec"
