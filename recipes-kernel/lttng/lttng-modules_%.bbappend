do_compile[lockfiles] += "${TMPDIR}/qti-techpack.lock"
